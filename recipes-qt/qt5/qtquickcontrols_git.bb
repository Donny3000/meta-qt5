require qt5-git.inc
require ${PN}.inc

SRCREV = "ea9add905768a26ce86ab542615a193296642732"
