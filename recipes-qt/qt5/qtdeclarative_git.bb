require qt5-git.inc
require ${PN}.inc

SRCREV = "aedcd57c84ac9d6b74816c13bdf3fde31e1132b5"
