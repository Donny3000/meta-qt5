require qt5-git.inc
require ${PN}.inc

SRCREV = "b088962950dbc4c6f0219de30b0d9a8cf47a3376"
