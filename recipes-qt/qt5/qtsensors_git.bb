require qt5-git.inc
require ${PN}.inc

SRCREV = "eee2eee734b4aa735d35f6c53d79c06c1c76425a"
