require qt5-git.inc
require ${PN}.inc

SRCREV = "e4453c92ee41943a3a1d67a725804a44e747f64e"
