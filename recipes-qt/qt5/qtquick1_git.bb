require qt5-git.inc
require ${PN}.inc

SRCREV = "c56f5d8848ce03cc6667804f815de47d2d8221fb"
