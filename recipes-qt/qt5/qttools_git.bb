require qt5-git.inc
require ${PN}.inc

SRCREV = "e7b791c8bb5e64a4c786bf370b10366815af704f"
