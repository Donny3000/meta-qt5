require qt5-git.inc
require ${PN}.inc

SRCREV = "9cbddccc24cdd4b51285ea9ecbf851f3eba2cd31"
